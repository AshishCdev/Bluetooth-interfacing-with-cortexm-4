# Keil uVision project hello_launcpad.uvproj, settings and files
target Target 1 (ARM-ADS)
  device: TM4C123GH6PM Texas Instruments
  cpu: IRAM(0x20000000-0x20007FFF) IROM(0-0x3FFFF) CLOCK(16000000) CPUTYPE("Cortex-M4") FPU2
  output: hello_launcpad +hex
  c flags: Optim=1 uC99=1 wLevel=2
  memory RVCT4: ROM 0x0 size 0x40000
  memory RVCT9: RAM 0x20000000 size 0x8000
  group Source Group 1
    ./: startup_TM4C123.s main_file.c
    C:/Keil/ARM/INC/TI/TM4C123/: system_TM4C123.h TM4C123GH6PM.h
    C:/Keil/ARM/Startup/TI/TM4C123/: system_TM4C123.c
    C:/Keil/ARM/INC/TI/TM4C123/my_headers/: gpio.c delay.c delay.h UART0.h UART0.c
